# Keil uVision project Wireless_Smart_Alarm.uvprojx, settings and files
target WEY (ARM-ADS)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Wireless_Smart_Alarm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TEACHING\GPIO;..\USER;..\TEACHING\LCD1602;..\TEACHING\TIMER;..\TEACHING\ADC;..\TEACHING\TIMER;..\TEACHING\NRF24L01;..\TEACHING\SPI;..\TEACHING\DHT11;..\TEACHING\USART3
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group TEACHING
    ../TEACHING/GPIO/: gpio.c
    ../TEACHING/LCD1602/: lcd1602.c
    ../TEACHING/TIMER/: timer.c
    ../TEACHING/NRF24L01/: 24l01.c
    ../TEACHING/SPI/: spi.c
    ../TEACHING/DHT11/: dht11.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
